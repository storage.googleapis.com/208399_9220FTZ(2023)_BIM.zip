Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-06-09T05:26:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 09 05:26:11 2023 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\2d5fe212-35a3-4fa8-b88f-d7c6fee47d5a\3e90d70f-524d-4f7f-b822-0399d7c73a24\ifc * Database version: 5507 * Database creation date: Fri Jun 09 05:26:11 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 09 05:26:11 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 09 05:26:11 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 9220FTZ Washbasin faucet, 230/9 V, Bluetooth, 9220FTZ(2023):9220FTZ Washbasin faucet, 230/9 V, Bluetooth:379652
In: Level 1
Type - PredefinedType: FAUCET; Material: Fine Textured - Black, Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 163.081 mm; NominalHeight: 135.012 mm; NominalWidth: 69.2863 mm
Type - Electrical - Bluetooth: 5.x (D060576); Electrical Connection: 230 / 9 V; Operating Voltage: 9 V; Protection Class: IP 55 / transformer IP 20
Type - General - Author: BIMStone; BIMObjectName: 9220FTZ(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - EAN Number: 6414150101748; EMC Directive: 2014/53/EU , 2011/65/EU; EN Standard: EN 15091; ETIM Class Number: EC010340 Electronic tap; LVI Number: 6110428; Noise Class: I (ISO 3822); NRF Number: 4203729; RSK Number: 8430030; Sales Package dimensions (LxWxH): 284 x 191 x 83.5; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/9220FTZ; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/9220FTZ; URL WEEE: http://static.oras.com/WEEE/9220FTZ; VVS Number: 704280504
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/9220FTZ; Catalog Drawing URL: http://static.oras.com/catdrw/9220FTZ; Dimension Drawing URL: http://static.oras.com/dimdrw/9220FTZ; FDV Document URL: http://www.oras.com/datasheet/9220FTZ/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/9220FTZ; Group: Washbasin faucet; Long Marketing: Electra 92 series is giving you a whole new modern design with its rounded square body and spout. Giving you new fresh and updated design. Design compliments the new trends of the modern bathroom with its more squared design. Key Features Aerator with Tilt function +/- 10° for more flexible installation Newest Sensor technology for better detection and operation comfort Bluetooth technology for easy adjustment to personalize settings Antiscalding protection Temperature measurement Digital Network Service Power Plug; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/9220FTZ; Model: 9220FTZ Washbasin faucet, 230/9 V, Bluetooth; Name_en: 9220FTZ Washbasin faucet, 230/9 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 9220FTZ; Product Family: Oras Electra Digital; Product Image URL: http://static.oras.com/image/9220FTZ; Product URL: http://static.oras.com/9220FTZ; Technical DataSheet URL: http://www.oras.com/datasheet/9220FTZ/en; Type Name: 9220FTZ Washbasin faucet, 230/9 V, Bluetooth; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: 3S-installation system for safe and simple mounting; Aerator: PCA® - constant flow rate regardless of pressure variations;Adjustable flow angle; Afterflow Period: 3 s (1-20 s); Automatic Flush Frequency: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Backflow Prevention EN1717: EB; Connection: Flexible inlet pipes; Connection Size: G3/8; Electronic Parts: ;Power supply;Light indicated function(s); Flow Rate At 300kPa With Flow Controller: 0.00317832 m3/s; Installation Type: Deck mounted; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 2 min (1 - 1800 s); Mechanical Parts: Mixing valve for manual temperature control;Non-return valve(s);Litter filter(s); Mounting Holes: 1 hole; Operating Distance: 20-130 mm (110/130/160 mm); Pressure Loss With Flow 01ls: 240000 Pa; Spout Projection: 117 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature Adjustments: Adjustable hot water stop (included, retrofittable); Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 9220FTZ(2023); Features: Touchless;Plug transformer;Bluetooth®;Lead free; Finish: Polished; Grade: n/a; Material: Composite; ModelNumber: n/a; ModelReference: 9220FTZ; Name: 9220FTZ Washbasin faucet, 230/9 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 70x165x135 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 9220FTZ Washbasin faucet, 230/9 V, Bluetooth; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 9220FTZ; Manufacturer: Oras
Pset_ProductRequirements - Name: 9220FTZ Washbasin faucet, 230/9 V, Bluetooth; Category: Plumbing Fixtures
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.043771 m2; Volume: 0.00153024 m3
Identity Data - Mark: 14
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 9220FTZ(2023): 9220FTZ Washbasin faucet, 230/9 V, Bluetooth; Family and Type: 9220FTZ(2023): 9220FTZ Washbasin faucet, 230/9 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 9220FTZ(2023): 9220FTZ Washbasin faucet, 230/9 V, Bluetooth; Type Id: 9220FTZ(2023): 9220FTZ Washbasin faucet, 230/9 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
